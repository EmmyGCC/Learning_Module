# IAR project Backup of switch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030C8 ST STM32F030C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030x8
  ICCARM.CCIncludePath2: CMSIS\Include; CODE\CPU; CODE\WIRELESS; CODE\小I; CODE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: switch.hex
  ILINK.IlinkOutputFile: switch.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group CMSIS
    CMSIS/: startup_stm32f030x8.s system_stm32f0xx.c
    CMSIS/Include/: stm32f030x8.h stm32f0xx.h
  group CODE
    CODE/小I/: aes.c crc16.c frame_process.c hk_device.c rsa.c
    CODE/: stm32f0xx_it.c
  group CPU
    CODE/CPU/: m0_systick.c mcu.c stm32f0_eeprom.c stm32f0_exint.c stm32f0_gpio.c stm32f0_iwdg.c stm32f0_peripheral.c stm32f0_rcc.c stm32f0_spi.c stm32f0_usart.c
  group MAIN
    MAIN/: main.c
  group WireLess
    CODE/WIRELESS/: wireless_app.c wireless_drv.c
