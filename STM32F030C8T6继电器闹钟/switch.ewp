# IAR project switch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030C8 ST STM32F030C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030x8
  ICCARM.CCIncludePath2: CMSIS\Include; CODE\CPU; CODE; CODE\Protocol\public_; CODE\WIRELESS\Si446x; CODE\WIRELESS; CODE\Protocol
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 继电器Alarm_V1.0.hex
  ILINK.IlinkOutputFile: switch.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; STM32F030x8
  ICCARM.CCIncludePath2: CMSIS\Include; CODE\CPU; CODE\小I; CODE; CODE\Inc; CODE\WIRELESS\Si446x
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group CMSIS
    CMSIS/: startup_stm32f030x8.s system_stm32f0xx.c
    CMSIS/Include/: stm32f030x8.h stm32f0xx.h
  group CODE
    CODE/: stm32f0xx_it.c
  group CPU
    CODE/CPU/: m0_systick.c mcu.c stm32f0_eeprom.c stm32f0_exint.c stm32f0_gpio.c stm32f0_iwdg.c stm32f0_peripheral.c stm32f0_rcc.c stm32f0_spi.c stm32f0_usart.c
  group MAIN
    MAIN/: main.c
    CODE/Protocol/public_/: protocol_data_def_struct.h
  group Protocol
    CODE/Protocol/: dev_mate_interface.c device_basic_info.c frame_process.c hk_device.c net_layer_api.c net_route_info.c uart_interface.c
  group Protocol/Public_Protocol
    CODE/Protocol/public_/: 74.c aes.c app_layer_api.c carrier.c carrier_layer_api.c crc16.c encrypt.c rsa.c system_func.c
  group WireLess
    CODE/WIRELESS/: rf_interface.c
  group WireLess/SI4438
    CODE/WIRELESS/Si446x/: radio.c radio_comm.c radio_hal.c si446x_api_lib.c
