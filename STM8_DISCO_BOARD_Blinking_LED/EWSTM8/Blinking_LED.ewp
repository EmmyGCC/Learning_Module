# IAR project Blinking_LED.ewp, settings and files
configuration STM8L001J3 (STM8)
  General.GenDeviceSelectMenu: STM8L050J3 STM8L050J3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_LD_VL
  ICCSTM8.CCIncludePath2: ..\STM8L050J3\inc; ..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\STM8-SO8_Discovery
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8L050J3_Blinking_LED.hex
  ILINK.IlinkOutputFile: Blinking_LED.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM8L050J3 (STM8, debug)
  as the first configuration, except:
  ICCSTM8.CCIncludePath2: ..\STM8L050J3\inc; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8-SO8_Discovery
configuration STM8S001J3 (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S001J3 STM8S001J3
  ICCSTM8.CCDefines: STM8S001
  ICCSTM8.CCIncludePath2: ..\STM8S001J3\inc; ..\..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8-SO8_Discovery
  OBJCOPY.OOCOutputFile: STM8S001J3_Blinking_LED.hex
  group Drivers/BSP
    ../STM8-SO8_Discovery/: stm8_so8_disco.c
  group Drivers/STM8L10x_StdPeriph_Driver
    ../../../Libraries/STM8L10x_StdPeriph_Driver/src/: stm8l10x_awu.c stm8l10x_clk.c stm8l10x_exti.c stm8l10x_gpio.c stm8l10x_tim2.c stm8l10x_tim4.c
  group Drivers/STM8L15x_StdPeriph_Driver
    ../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_tim4.c
  group Drivers/STM8S_StdPeriph_Driver
    ../../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_tim4.c
  group User/STM8L001J3
    ../STM8L001J3/src/: main.c stm8l10x_it.c
  group User/STM8L050J3
    ../STM8L050J3/src/: main.c stm8l15x_it.c
  group User/STM8S001J3
    ../STM8S001J3/src/: main.c stm8s_it.c
