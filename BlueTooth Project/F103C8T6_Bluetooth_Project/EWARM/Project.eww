<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F103C8T6_TEST_Project.ewp</path>
  </project>
  <batchBuild />
</workspace>
